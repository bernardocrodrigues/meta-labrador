FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

# SRC_URI += "file://devtool-fragment.cfg"

# https://git.kernel.org/pub/scm/linux/kernel/git/mani/linux-actions.git/