inherit extrausers

# EXTRA_USERS_PARAMS = "usermod -P caninos root;"
# EXTRA_IMAGE_FEATURES = "debug-tweaks"